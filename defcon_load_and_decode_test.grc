options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: mpsk_stage6
    output_language: python
  states: {}

blocks:
- name: const_pts
  id: variable
  parameters:
    value: '110'
  states: {}
- name: dc
  id: variable
  parameters:
    value: '1'
  states: {}
- name: dec
  id: variable
  parameters:
    value: int(interp*samp_rate_in/resample_rate)
  states: {state: disabled}
- name: eq_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,1,1,1'
    label: 'Equalizer: rate'
    orient: Qt.Horizontal
    start: '0.0'
    step: '0.001'
    stop: '0.1'
    value: 0.01 *0
  states: {}
- name: eq_sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: interp
  id: variable
  parameters:
    comment: interp of 1 seems to work best
    value: '1'
  states: {state: disabled}
- name: intrp
  id: variable
  parameters:
    value: '4'
  states: {}
- name: lpf_cutoff_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 2,1,1,1'
    label: LPF Cutoff Freq
    orient: Qt.Horizontal
    start: '100000'
    step: '50000'
    stop: 1.2e6
    value: '250000'
  states: {state: disabled}
- name: lpf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 2,0,1,1'
    label: '[LPF] Gain'
    orient: Qt.Horizontal
    start: '0'
    step: '.25'
    stop: '20'
    value: '4.5'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: 4*3*2
  states: {}
- name: nfilts_2
  id: variable
  parameters:
    value: intrp*4*3*2
  states: {}
- name: pcs_sps_in
  id: variable
  parameters:
    value: '4'
  states: {}
- name: pcs_sps_out
  id: variable
  parameters:
    value: '2'
  states: {}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,2,1,1'
    label: 'Phase: Bandwidth'
    orient: Qt.Horizontal
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: rast_cols
  id: variable
  parameters:
    value: 110*2
  states: {}
- name: rast_up
  id: variable
  parameters:
    value: 1/1000
  states: {}
- name: resample_rate
  id: variable
  parameters:
    value: samp_rate_out * eq_sps * pcs_sps_in / pcs_sps_out
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 1,0,1,1'
    label: RF Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '80'
    value: '28'
  states: {}
- name: rolloff
  id: variable
  parameters:
    comment: .7 waaaay cleaner than .35
    value: .35*2
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(pcs_sps_in), rolloff, 11*pcs_sps_in*nfilts)
  states: {}
- name: rrc_taps_2
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts_2, nfilts_2, 1.0/float(intrp*pcs_sps_in), 0.35, 11*intrp*pcs_sps_in*nfilts_2)
  states: {}
- name: samp_rate_in
  id: variable
  parameters:
    comment: sample rate 8-20 MSPS
    value: resample_rate*10
  states: {state: disabled}
- name: samp_rate_out
  id: variable
  parameters:
    value: 300e3
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0, 0.25-0.25j, 0.50 + 0.10j, -0.3 + 0.2j]'
  states: {}
- name: timing_loop_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,0,1,1'
    label: 'Time: BW'
    orient: Qt.Horizontal
    start: '0.0'
    step: '0.01'
    stop: '0.2'
    value: '6.28/100.0 '
    widget: slider
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    const_points: '[0.383+0.924j, 0.924+0.383j, 0.924-0.383j, 0.383-0.924j, -0.383-0.924j, -0.924-0.383j, -0.924+0.383j, -0.383+0.924j]'
    dims: '1'
    precision: '0'
    rot_sym: '8'
    sym_map: '[1,0,7,6,5,4,3,2]'
    type: calcdist
  states: {state: disabled}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    const_points: '[0.383+0.924j, 0.924+0.383j, 0.924-0.383j, 0.383-0.924j, -0.383-0.924j, -0.924-0.383j, -0.924+0.383j, -0.383+0.924j, 0]'
    dims: '1'
    precision: '8'
    rot_sym: '4'
    sym_map: '[1,0,7,6,5,4,3,2,8]'
    type: calcdist
  states: {}
- name: blocks_and_const_xx_0
  id: blocks_and_const_xx
  parameters:
    const: '8'
    type: byte
  states: {state: disabled}
- name: blocks_and_const_xx_0_0
  id: blocks_and_const_xx
  parameters:
    const: '8'
    type: byte
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '2'
    type: byte
  states: {state: bypassed}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1.5'
    type: complex
  states: {}
- name: blocks_or_xx_0
  id: blocks_or_xx
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_or_xx_0_0
  id: blocks_or_xx
  parameters:
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '320000'
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: works great with recorded_example_shortest_3.wav
    file: /home/pentoo/defcon27_badge_sdr/recorder_10.552_PCsync_0PPM_short.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: /home/pentoo/defcon27_badge_sdr/recorded_glitch_10.400.wav
    nchan: '2'
    repeat: 'True'
  states: {state: disabled}
- name: controls
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,3
    label0: Receiver
    num_tabs: '1'
  states: {}
- name: digital_cma_equalizer_cc_0
  id: digital_cma_equalizer_cc
  parameters:
    modulus: '1'
    mu: eq_gain
    num_taps: '15'
    sps: eq_sps
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: variable_constellation_0
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: variable_constellation_0
  states: {}
- name: digital_constellation_decoder_cb_0_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: variable_constellation_0
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '8'
    w: phase_bw
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '8'
    w: phase_bw
  states: {}
- name: digital_costas_loop_cc_0_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '8'
    w: phase_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '8'
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '8'
  states: {}
- name: digital_diff_decoder_bb_0_0_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '8'
  states: {}
- name: digital_lms_dd_equalizer_cc_0
  id: digital_lms_dd_equalizer_cc
  parameters:
    cnst: variable_constellation_0
    mu: eq_gain
    num_taps: '1'
    sps: eq_sps
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: timing_loop_bw
    max_dev: '1.5'
    osps: pcs_sps_out
    sps: pcs_sps_in
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_pfb_clock_sync_xxx_0_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: timing_loop_bw
    max_dev: '1.5'
    osps: pcs_sps_out
    sps: pcs_sps_in
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_pfb_clock_sync_xxx_0_0_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts_2
    init_phase: nfilts/2
    loop_bw: timing_loop_bw
    max_dev: '1.5'
    osps: '1'
    sps: pcs_sps_in*intrp
    taps: rrc_taps_2
    type: ccf
  states: {}
- name: digital_probe_mpsk_snr_est_c_0
  id: digital_probe_mpsk_snr_est_c
  parameters:
    alpha: '0.001'
    msg_nsamples: '110'
    type: '0'
  states: {state: disabled}
- name: digital_probe_mpsk_snr_est_c_0_0
  id: digital_probe_mpsk_snr_est_c
  parameters:
    alpha: '0.001'
    msg_nsamples: '10000'
    type: '0'
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: received@0:0,1
    name: '"Costas Loop Output"'
    size: const_pts
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: received@0:1,1
    name: '"Costas Loop Output"'
    size: const_pts
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: received@0:2,1
    name: '"Costas Loop Output"'
    size: const_pts
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    gui_hint: received@0:0,0
    size: const_pts
    type: complex
  states: {}
- name: qtgui_const_sink_x_1_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: received@0:1,0
    size: const_pts
    type: complex
  states: {}
- name: qtgui_const_sink_x_1_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: received@0:2,0
    size: const_pts
    type: complex
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    gui_hint: received@0:0,2
    ncols: rast_cols
    nrows: '250'
    samp_rate: samp_rate_out
    type: byte
    update_time: rast_up
    zmax: '7'
    zmin: '0'
  states: {}
- name: qtgui_time_raster_sink_x_0_0
  id: qtgui_time_raster_sink_x
  parameters:
    gui_hint: received@0:1,2
    ncols: rast_cols
    nrows: '250'
    samp_rate: samp_rate_out
    type: byte
    update_time: rast_up
    zmax: '8'
    zmin: '0'
  states: {}
- name: qtgui_time_raster_sink_x_0_0_0
  id: qtgui_time_raster_sink_x
  parameters:
    gui_hint: received@0:2,2
    ncols: rast_cols
    nrows: '250'
    samp_rate: samp_rate_out
    type: byte
    update_time: rast_up
    zmax: '8'
    zmin: '0'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: increase by 4x
    decim: dc
    interp: intrp*dc
    taps: ''
    type: ccc
  states: {}
- name: received
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,2,3
    label0: Constellation
    num_tabs: '1'
  states: {}

connections:
- [blocks_and_const_xx_0, '0', blocks_or_xx_0, '1']
- [blocks_and_const_xx_0_0, '0', blocks_or_xx_0_0, '1']
- [blocks_delay_0_0, '0', qtgui_time_raster_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_float_to_complex_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_throttle_0, '0']
- [blocks_or_xx_0, '0', qtgui_time_raster_sink_x_0_0_0, '0']
- [blocks_or_xx_0_0, '0', qtgui_time_raster_sink_x_0_0, '0']
- [blocks_throttle_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [blocks_throttle_0, '0', digital_pfb_clock_sync_xxx_0_0, '0']
- [blocks_throttle_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [blocks_wavfile_source_0_0, '0', blocks_float_to_complex_0_0, '0']
- [blocks_wavfile_source_0_0, '1', blocks_float_to_complex_0_0, '1']
- [digital_cma_equalizer_cc_0, '0', digital_costas_loop_cc_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', blocks_and_const_xx_0_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_decoder_cb_0_0_0, '0', blocks_and_const_xx_0, '0']
- [digital_constellation_decoder_cb_0_0_0, '0', digital_diff_decoder_bb_0_0_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', digital_probe_mpsk_snr_est_c_0_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_probe_mpsk_snr_est_c_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_costas_loop_cc_0_0_0, '0', digital_constellation_decoder_cb_0_0_0, '0']
- [digital_costas_loop_cc_0_0_0, '0', qtgui_const_sink_x_0_0_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_delay_0_0, '0']
- [digital_diff_decoder_bb_0_0, '0', blocks_or_xx_0_0, '0']
- [digital_diff_decoder_bb_0_0_0, '0', blocks_or_xx_0, '0']
- [digital_diff_decoder_bb_0_0_0, '0', qtgui_time_raster_sink_x_0_0_0, '0']
- [digital_lms_dd_equalizer_cc_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_cma_equalizer_cc_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_const_sink_x_1, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', digital_lms_dd_equalizer_cc_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', qtgui_const_sink_x_1_0, '0']
- [digital_pfb_clock_sync_xxx_0_0_0, '0', digital_costas_loop_cc_0_0_0, '0']
- [digital_pfb_clock_sync_xxx_0_0_0, '0', qtgui_const_sink_x_1_0_0, '0']
- [digital_probe_mpsk_snr_est_c_0, noise, digital_costas_loop_cc_0_0, noise]
- [digital_probe_mpsk_snr_est_c_0_0, snr, digital_costas_loop_cc_0, noise]
- [rational_resampler_xxx_0, '0', digital_pfb_clock_sync_xxx_0_0_0, '0']

metadata:
  file_format: 1
