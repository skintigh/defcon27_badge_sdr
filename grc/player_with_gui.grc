options:
  parameters:
    author: Seth Kintigh
    generate_options: qt_gui
    id: player
    output_language: python
    run_options: run
    title: Player with Gui
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Freq
    orient: Qt.Horizontal
    start: 10.3e6
    step: '10000'
    stop: 10.6e6
    value: 10.55515e6
  states: {state: disabled}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Freq
    orient: Qt.Horizontal
    start: 10.3e6
    step: '10000'
    stop: 10.6e6
    value: 10.569e6
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Freq
    orient: Qt.Horizontal
    start: 10.3e6
    step: '10000'
    stop: 10.6e6
    value: 10.5552e6
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '1190550'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '1200000'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      .2 with loop almost touching
      1.0 with AM antenna 1CM away

      loop close 4pct .6

      .3 loop behind ant
      	missed 3
      	doubled first (size 21)
      	missed 2nd
      	doubled 2nd (size 12)
      	success! didn't close gui this time


      With antenna 2.5 inches away, pointed slight down and to the left:
      const 1
      RF gain 40 (but not sure that does anything?)
      IF and BB at 0 (also seems to do nothing)
    const: '1'
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/pentoo/defcon27_badge_sdr/synthetic_signal.wav
    nchan: '2'
    repeat: 'True'
  states: {state: disabled}
- name: blocks_wavfile_source_0_3
  id: blocks_wavfile_source
  parameters:
    file: /home/pentoo/defcon27_badge_sdr/POC_B32.wav
    nchan: '2'
    repeat: 'False'
  states: {state: disabled}
- name: blocks_wavfile_source_0_3_0
  id: blocks_wavfile_source
  parameters:
    file: /home/pentoo/defcon27_badge_sdr/POC_printf_Goon_len5_00000B9D_E.wav
    nchan: '2'
    repeat: 'False'
  states: {state: disabled}
- name: blocks_wavfile_source_0_3_1_0_0_0_0
  id: blocks_wavfile_source
  parameters:
    comment: only works with breakpoints?
    file: /home/pentoo/defcon27_badge_sdr/attack_examples/POC_seth_was_here_all__print_recv.wav
    nchan: '2'
    repeat: 'False'
  states: {state: disabled}
- name: blocks_wavfile_source_0_3_1_0_0_0_0_0
  id: blocks_wavfile_source
  parameters:
    file: /home/pentoo/defcon27_badge_sdr/POC_seth_was_here_all__print_recv_faster.wav
    nchan: '2'
    repeat: 'False'
  states: {state: disabled}
- name: blocks_wavfile_source_0_3_1_0_0_0_0_0_0
  id: blocks_wavfile_source
  parameters:
    file: /home/pentoo/defcon27_badge_sdr/badge_stock_with_jacked_NFMI_POC/POC_seth_was_here_all_slow.wav
    nchan: '2'
    repeat: 'False'
  states: {state: disabled}
- name: blocks_wavfile_source_0_3_1_0_0_0_0_0_0_0
  id: blocks_wavfile_source
  parameters:
    comment: length 51
    file: /home/pentoo/defcon27_badge_sdr/POC_seth__print_recv__R456__2E2F__042D__Seth0d0a0045.wav
    nchan: '2'
    repeat: 'False'
  states: {state: disabled}
- name: blocks_wavfile_source_0_3_1_0_0_0_0_0_0_0_0
  id: blocks_wavfile_source
  parameters:
    file: /home/pentoo/defcon27_badge_sdr/POC_seth__print_recv__R456__2E2F__042D__0d0a09_Seth_was_here_0d0a00E.wav
    nchan: '2'
    repeat: 'False'
  states: {state: disabled}
- name: blocks_wavfile_source_0_3_1_0_0_0_0_0_0_1
  id: blocks_wavfile_source
  parameters:
    comment: doesn't work
    file: /home/pentoo/defcon27_badge_sdr/POC_seth__print_recv__R456__2E2F__042D__0d0a09_Seth_was_here_0d0a00E.wav
    nchan: '2'
    repeat: 'False'
  states: {state: disabled}
- name: blocks_wavfile_source_0_4
  id: blocks_wavfile_source
  parameters:
    comment: 1.2MSps, 10.552MHz, long tail, sends 0x123456789001ff 10.569 better with real ant
    file: /home/pentoo/defcon27_badge_sdr/recordings/new_standard_signal.wav
    nchan: '2'
    repeat: 'True'
  states: {state: disabled}
- name: blocks_wavfile_source_0_4_0
  id: blocks_wavfile_source
  parameters:
    comment: |-
      Win game on badge with modified NFMI firmware
      1.2MSPS 10.569MHz
      mostly works. 
      0.5 const and -40 RF db help? 
      (At least when recv is working at 40dB RF and 5x amp)
      If nothing happens, badge badge probably has crashed
      Best to reboot if there's half a packet stuck in a the buffer?
    file: /home/pentoo/defcon27_badge_sdr/synthetic_signal_win_DC27_game_on_hacked_NFMI_FW.wav
    nchan: '2'
    repeat: 'False'
  states: {state: disabled}
- name: blocks_wavfile_source_0_4_0_0
  id: blocks_wavfile_source
  parameters:
    comment: |-
      Win game on badge with modified NFMI firmware
      1.2MSPS 10.569MHz
      mostly works. 
      0.5 const and -40 RF db help? 
      (At least when recv is working at 40dB RF and 5x amp)
      If nothing happens, badge badge probably has crashed
      Best to reboot if there's half a packet stuck in a the buffer?
    file: /home/pentoo/defcon27_badge_sdr/synthetic_signal_win_DC27_game.wav
    nchan: '2'
    repeat: 'True'
  states: {state: disabled}
- name: blocks_wavfile_source_0_4_0_1
  id: blocks_wavfile_source
  parameters:
    comment: |-
      Print seth with hacked NFMI FW on stock badge FW
      1.2MSPS 10.569MHz

      mostly works. 
      0.5 const and -40 RF db help? 
      (At least when recv is working at 40dB RF and 5x amp)
      If nothing happens, badge badge probably has crashed
      Best to reboot if there's half a packet stuck in a the buffer?
    file: /home/pentoo/defcon27_badge_sdr/synthetic_print_seth.wav
    nchan: '2'
    repeat: 'False'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '0'
    bw0: '300000'
    freq0: freq
    gain0: '40'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '256'
    plotconst: 'False'
    plottime: 'False'
    rate: '100'
    type: complex
    wintype: firdes.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    update_time: '0.004'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_float_to_complex_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', osmosdr_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [blocks_wavfile_source_0_3, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0_3, '1', blocks_float_to_complex_0, '1']
- [blocks_wavfile_source_0_3_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0_3_0, '1', blocks_float_to_complex_0, '1']
- [blocks_wavfile_source_0_3_1_0_0_0_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0_3_1_0_0_0_0, '1', blocks_float_to_complex_0, '1']
- [blocks_wavfile_source_0_3_1_0_0_0_0_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0_3_1_0_0_0_0_0, '1', blocks_float_to_complex_0, '1']
- [blocks_wavfile_source_0_3_1_0_0_0_0_0_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0_3_1_0_0_0_0_0_0, '1', blocks_float_to_complex_0, '1']
- [blocks_wavfile_source_0_3_1_0_0_0_0_0_0_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0_3_1_0_0_0_0_0_0_0, '1', blocks_float_to_complex_0, '1']
- [blocks_wavfile_source_0_3_1_0_0_0_0_0_0_0_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0_3_1_0_0_0_0_0_0_0_0, '1', blocks_float_to_complex_0, '1']
- [blocks_wavfile_source_0_3_1_0_0_0_0_0_0_1, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0_3_1_0_0_0_0_0_0_1, '1', blocks_float_to_complex_0, '1']
- [blocks_wavfile_source_0_4, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0_4, '1', blocks_float_to_complex_0, '1']
- [blocks_wavfile_source_0_4_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0_4_0, '1', blocks_float_to_complex_0, '1']
- [blocks_wavfile_source_0_4_0_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0_4_0_0, '1', blocks_float_to_complex_0, '1']
- [blocks_wavfile_source_0_4_0_1, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0_4_0_1, '1', blocks_float_to_complex_0, '1']

metadata:
  file_format: 1
