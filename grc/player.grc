options:
  parameters:
    author: asd
    generate_options: no_gui
    id: player
    output_language: python
    run_options: run
    title: asdasdas
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1200000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1190550'
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/pentoo/defcon27_badge_sdr/recordings/new_standard_signal.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_2
  id: blocks_wavfile_source
  parameters:
    file: /home/pentoo/defcon27_badge_sdr/recorder.wav
    nchan: '2'
    repeat: 'False'
  states: {state: disabled}
- name: blocks_wavfile_source_0_3
  id: blocks_wavfile_source
  parameters:
    file: /home/pentoo/defcon27_badge_sdr/POC_B32.wav
    nchan: '2'
    repeat: 'False'
  states: {state: disabled}
- name: blocks_wavfile_source_0_3_0
  id: blocks_wavfile_source
  parameters:
    file: /home/pentoo/defcon27_badge_sdr/POC_printf_Goon_len5_00000B9D_E.wav
    nchan: '2'
    repeat: 'False'
  states: {state: disabled}
- name: blocks_wavfile_source_0_3_1
  id: blocks_wavfile_source
  parameters:
    file: /home/pentoo/defcon27_badge_sdr/POC_B24.wav
    nchan: '2'
    repeat: 'False'
  states: {state: disabled}
- name: blocks_wavfile_source_0_3_1_0
  id: blocks_wavfile_source
  parameters:
    file: /home/pentoo/defcon27_badge_sdr/POC_seth_was_here_part2.wav
    nchan: '2'
    repeat: 'False'
  states: {state: disabled}
- name: blocks_wavfile_source_0_3_1_0_0
  id: blocks_wavfile_source
  parameters:
    file: /home/pentoo/defcon27_badge_sdr/POC_seth_was_here_part3.wav
    nchan: '2'
    repeat: 'False'
  states: {state: disabled}
- name: blocks_wavfile_source_0_3_1_0_0_0
  id: blocks_wavfile_source
  parameters:
    file: /home/pentoo/defcon27_badge_sdr/POC_seth_was_here_part4.wav
    nchan: '2'
    repeat: 'False'
  states: {state: disabled}
- name: blocks_wavfile_source_0_3_1_0_0_0_0
  id: blocks_wavfile_source
  parameters:
    file: /home/pentoo/defcon27_badge_sdr/POC_seth_was_here_all__print_recv.wav
    nchan: '2'
    repeat: 'False'
  states: {state: disabled}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '0'
    bw0: '300000'
    freq0: 10.5551e6
    gain0: '0'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [blocks_float_to_complex_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_complex_0, '0', osmosdr_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', osmosdr_sink_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [blocks_wavfile_source_0_2, '1', blocks_float_to_complex_0, '1']
- [blocks_wavfile_source_0_3, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0_3, '1', blocks_float_to_complex_0, '1']
- [blocks_wavfile_source_0_3_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0_3_0, '1', blocks_float_to_complex_0, '1']
- [blocks_wavfile_source_0_3_1, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0_3_1, '1', blocks_float_to_complex_0, '1']
- [blocks_wavfile_source_0_3_1_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0_3_1_0, '1', blocks_float_to_complex_0, '1']
- [blocks_wavfile_source_0_3_1_0_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0_3_1_0_0, '1', blocks_float_to_complex_0, '1']
- [blocks_wavfile_source_0_3_1_0_0_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0_3_1_0_0_0, '1', blocks_float_to_complex_0, '1']
- [blocks_wavfile_source_0_3_1_0_0_0_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0_3_1_0_0_0_0, '1', blocks_float_to_complex_0, '1']

metadata:
  file_format: 1
