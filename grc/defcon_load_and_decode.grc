options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: player
    output_language: python
  states: {}

blocks:
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 1,2,1,1'
    label: BB Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {state: disabled}
- name: dec
  id: variable
  parameters:
    value: int(interp*samp_rate_in/resample_rate)
  states: {}
- name: eq_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,1,1,1'
    label: 'Equalizer: rate'
    orient: Qt.Horizontal
    start: '0.0'
    step: '0.001'
    stop: '0.1'
    value: 0.01 *0
    widget: slider
  states: {}
- name: eq_sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 1,1,1,1'
    label: IF Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {state: disabled}
- name: interp
  id: variable
  parameters:
    comment: interp of 1 seems to work best
    value: '1'
  states: {}
- name: lpf_cutoff_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 2,1,1,1'
    label: LPF Cutoff Freq
    orient: Qt.Horizontal
    start: '100000'
    step: '50000'
    stop: 1.2e6
    value: '250000'
  states: {state: disabled}
- name: lpf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 2,0,1,1'
    label: '[LPF] Gain'
    orient: Qt.Horizontal
    start: '0'
    step: '.25'
    stop: '20'
    value: '4.5'
  states: {state: disabled}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: pcs_sps_in
  id: variable
  parameters:
    value: '4'
  states: {}
- name: pcs_sps_out
  id: variable
  parameters:
    value: '2'
  states: {}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,2,1,1'
    label: 'Phase: Bandwidth'
    orient: Qt.Horizontal
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: resample_rate
  id: variable
  parameters:
    value: samp_rate_out * eq_sps * pcs_sps_in / pcs_sps_out
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 1,0,1,1'
    label: RF Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '80'
    value: '28'
  states: {state: disabled}
- name: rolloff
  id: variable
  parameters:
    value: .35*2
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(pcs_sps_in), rolloff, 11*pcs_sps_in*nfilts)
  states: {}
- name: samp_rate_in
  id: variable
  parameters:
    comment: sample rate 8-20 MSPS
    value: resample_rate*10
  states: {}
- name: samp_rate_out
  id: variable
  parameters:
    value: 300e3
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0, 0.25-0.25j, 0.50 + 0.10j, -0.3 + 0.2j]'
  states: {}
- name: timing_loop_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,0,1,1'
    label: 'Time: BW'
    orient: Qt.Horizontal
    start: '0.0'
    step: '0.01'
    stop: '0.2'
    value: '6.28/100.0 '
    widget: slider
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    const_points: '[0.383+0.924j, 0.924+0.383j, 0.924-0.383j, 0.383-0.924j, -0.383-0.924j, -0.924-0.383j, -0.924+0.383j, -0.383+0.924j]'
    dims: '1'
    precision: '8'
    rot_sym: '4'
    sym_map: '[1,0,7,6,5,4,3,2]'
    type: calcdist
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '0x3020'
    type: short
  states: {}
- name: blocks_char_to_short_0
  id: blocks_char_to_short
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/pentoo/defcon27_badge_sdr/symbols.txt
    type: short
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: lpf_gain
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1.5'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '320000'
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/pentoo/defcon27_badge_sdr/recordings/new_standard_signal.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: controls
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,3
    label0: Receiver
    num_tabs: '1'
  states: {}
- name: digital_cma_equalizer_cc_0
  id: digital_cma_equalizer_cc
  parameters:
    modulus: '1'
    mu: eq_gain
    num_taps: '15'
    sps: eq_sps
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: variable_constellation_0
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '8'
    w: phase_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '8'
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '8'
  states: {state: bypassed}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: timing_loop_bw
    max_dev: '1.5'
    osps: pcs_sps_out
    sps: pcs_sps_in
    taps: rrc_taps
    type: ccf
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: bb_gain
    bw0: 400e3
    comment: |-
      10.544e6 seems to work
      10.59e6 didn't work well
      10.56e6 was a hair better but not perfects
      10.409e6 (10.559-.150) didn't work



      bw of 400k works way better than 1.2m
      bw 800k works
      600k works
      300k doesn't work as well as 400
      eyeballing the freq, it looks like 600k is the full band...
      600k better than 400k?

      69 30 30 is too strong?
      30 0 0 works far better than 30 20 20
      33 0 20 works well
      30 0 0 works better than 33 0 0
      50 0 0 waaaay better
      60 0 0 even better with 300k lpf 1 gain
      69 0 0 and 69 30 30 worse
      60 20 20 worse
      50 20 20 way worse
      55 0 0 way worse than 60 0 0
      cranked phasebw from *4 to *1, waaay better

      output is +/- 0.5, should I amplify?

      increasing gain to spread out the clouds made a huge improvement!
    freq0: 10.544e6
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: if_gain
    sample_rate: samp_rate_in
    sync: none
    type: fc32
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 'received@0: 0,0,1,1'
    name: '"Costas Loop Output"'
    size: '110'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate_in
    fc: '0'
    fftsize: '1024'
    gui_hint: 'received@0: 0,2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    gui_hint: 'received@0: 0,3'
    name: '"110"'
    ncols: '110'
    nrows: '250'
    samp_rate: samp_rate_out
    type: byte
    update_time: '0.01'
    zmax: '7'
    zmin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Rational Resampler output, keep under 2V?"'
    size: '64'
    srate: resample_rate
    type: complex
    ymax: '2'
    ymin: '-2'
    yunit: we
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: dec
    interp: interp
    taps: '1'
    type: ccc
  states: {state: disabled}
- name: received
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,2,3
    label0: Constellation
    num_tabs: '1'
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_file_sink_0, '0']
- [blocks_char_to_short_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', rational_resampler_xxx_0, '0']
- [blocks_throttle_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [digital_cma_equalizer_cc_0, '0', digital_costas_loop_cc_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_char_to_short_0, '0']
- [digital_diff_decoder_bb_0, '0', qtgui_time_raster_sink_x_0, '0']
- [digital_diff_decoder_bb_0_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_cma_equalizer_cc_0, '0']
- [osmosdr_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
