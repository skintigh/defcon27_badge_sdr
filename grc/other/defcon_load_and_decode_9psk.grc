options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: player
    output_language: python
  states: {}

blocks:
- name: constellation_8PSK_auto
  id: variable_constellation
  parameters:
    const_points: '[0.383+0.924j, 0.924+0.383j, 0.924-0.383j, 0.383-0.924j, -0.383-0.924j, -0.924-0.383j, -0.924+0.383j, -0.383+0.924j]'
    dims: '1'
    precision: '8'
    rot_sym: '8'
    soft_dec_lut: '''auto'''
    sym_map: '[1,0,7,6,5,4,3,2]'
    type: calcdist
  states: {state: disabled}
- name: constellation_9PSK_auto
  id: variable_constellation
  parameters:
    const_points: '[0.383+0.924j, 0.924+0.383j, 0.924-0.383j, 0.383-0.924j, -0.383-0.924j, -0.924-0.383j, -0.924+0.383j, -0.383+0.924j, 0]'
    dims: '1'
    precision: '8'
    rot_sym: '8'
    soft_dec_lut: '''auto'''
    sym_map: '[1,0,7,6,5,4,3,2,8]'
    type: calcdist
  states: {}
- name: dec
  id: variable
  parameters:
    value: int(interp*samp_rate_in/resample_rate)
  states: {}
- name: eq_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,1,1,1'
    label: 'Equalizer: rate'
    orient: Qt.Horizontal
    start: '0.0'
    step: '0.001'
    stop: '0.1'
    value: 0.01 *0
    widget: slider
  states: {}
- name: eq_sps
  id: variable
  parameters:
    value: '1'
  states: {}
- name: interp
  id: variable
  parameters:
    comment: interp of 1 seems to work best
    value: '1'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: pcs_sps_in
  id: variable
  parameters:
    value: '4'
  states: {}
- name: pcs_sps_out
  id: variable
  parameters:
    value: '1'
  states: {}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,2,1,1'
    label: 'Phase: Bandwidth'
    orient: Qt.Horizontal
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: resample_rate
  id: variable
  parameters:
    value: samp_rate_out * eq_sps * pcs_sps_in / pcs_sps_out
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: .35*3
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(pcs_sps_in), rolloff, 11*pcs_sps_in*nfilts)
  states: {}
- name: samp_rate_in
  id: variable
  parameters:
    comment: sample rate 8-20 MSPS
    value: resample_rate*10
  states: {}
- name: samp_rate_out
  id: variable
  parameters:
    value: 1190550/4
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0, 0.25-0.25j, 0.50 + 0.10j, -0.3 + 0.2j]'
  states: {}
- name: timing_loop_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,0,1,1'
    label: 'Time: BW'
    orient: Qt.Horizontal
    start: '0.0'
    step: '0.01'
    stop: '0.2'
    value: '6.28/100.0 '
    widget: slider
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '0x3020'
    type: short
  states: {state: disabled}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '0x3020'
    type: short
  states: {state: disabled}
- name: blocks_add_const_vxx_0_1
  id: blocks_add_const_vxx
  parameters:
    const: '0x3020'
    type: short
  states: {}
- name: blocks_add_const_vxx_0_1_0
  id: blocks_add_const_vxx
  parameters:
    const: '0x3020'
    type: short
  states: {}
- name: blocks_add_const_vxx_0_2
  id: blocks_add_const_vxx
  parameters:
    const: '0x3020'
    type: short
  states: {state: disabled}
- name: blocks_add_const_vxx_0_3
  id: blocks_add_const_vxx
  parameters:
    const: '0x3020'
    type: short
  states: {state: disabled}
- name: blocks_char_to_short_0
  id: blocks_char_to_short
  parameters: {}
  states: {state: disabled}
- name: blocks_char_to_short_0_0
  id: blocks_char_to_short
  parameters: {}
  states: {state: disabled}
- name: blocks_char_to_short_0_1
  id: blocks_char_to_short
  parameters: {}
  states: {}
- name: blocks_char_to_short_0_1_0
  id: blocks_char_to_short
  parameters: {}
  states: {}
- name: blocks_char_to_short_0_2
  id: blocks_char_to_short
  parameters: {}
  states: {state: disabled}
- name: blocks_char_to_short_0_3
  id: blocks_char_to_short
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ./symbols_map_diff.txt
    type: short
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: ./symbols_diff_diff.txt
    type: short
  states: {state: disabled}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: ./symbols_raw.txt
    type: short
  states: {}
- name: blocks_file_sink_0_1_0
  id: blocks_file_sink
  parameters:
    file: ./symbols_diff.txt
    type: short
  states: {}
- name: blocks_file_sink_0_2
  id: blocks_file_sink
  parameters:
    file: ./symbols_map_diff_diff.txt
    type: short
  states: {state: disabled}
- name: blocks_file_sink_0_3
  id: blocks_file_sink
  parameters:
    file: ./symbols_diff_map.txt
    type: short
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1.5'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '3200000'
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/pentoo/defcon27_badge_sdr/recordings/recorded_10.5551_PCsync_0PPM_119055_short.wav
    nchan: '2'
    repeat: 'True'
  states: {state: disabled}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: /home/pentoo/defcon27_badge_sdr/recordings/glitched_badge/recorded_glitch_10.400.wav
    nchan: '2'
    repeat: 'False'
  states: {}
- name: controls
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,3
    label0: Receiver
    num_tabs: '1'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation_9PSK_auto
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '8'
    w: phase_bw
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '8'
  states: {state: disabled}
- name: digital_diff_decoder_bb_0_0_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '8'
  states: {state: disabled}
- name: digital_diff_decoder_bb_0_0_0_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '8'
  states: {state: disabled}
- name: digital_diff_decoder_bb_0_0_1
  id: digital_diff_decoder_bb
  parameters:
    modulus: '8'
  states: {state: disabled}
- name: digital_diff_decoder_bb_0_0_1_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '8'
  states: {state: disabled}
- name: digital_diff_decoder_bb_0_0_2
  id: digital_diff_decoder_bb
  parameters:
    modulus: '8'
  states: {state: disabled}
- name: digital_diff_decoder_bb_0_0_3
  id: digital_diff_decoder_bb
  parameters:
    modulus: '8'
  states: {}
- name: digital_map_bb_0_0_0
  id: digital_map_bb
  parameters:
    map: '[1,0,7,6,5,4,3,2,0]'
  states: {state: disabled}
- name: digital_map_bb_0_0_0_0
  id: digital_map_bb
  parameters:
    map: '[7,6,5,4,3,2,1,0,8]'
  states: {state: disabled}
- name: digital_map_bb_0_0_0_0_0
  id: digital_map_bb
  parameters:
    map: '[7,6,5,4,3,2,1,0,8]'
  states: {state: disabled}
- name: digital_map_bb_0_0_0_0_1
  id: digital_map_bb
  parameters:
    map: '[7,6,5,4,3,2,1,0,8]'
  states: {state: disabled}
- name: digital_map_bb_0_0_0_1
  id: digital_map_bb
  parameters:
    map: '[1,0,7,6,5,4,3,2,0]'
  states: {state: disabled}
- name: digital_map_bb_0_0_0_2
  id: digital_map_bb
  parameters:
    map: '[1,0,7,6,5,4,3,2,0]'
  states: {state: disabled}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: timing_loop_bw
    max_dev: '0.01'
    osps: pcs_sps_out
    sps: pcs_sps_in
    taps: rrc_taps
    type: ccf
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 'received@0: 0,0,1,1'
    name: '"Costas Loop Output"'
    size: '110'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate_in
    fc: '0'
    fftsize: '1024'
    gui_hint: 'received@0: 0,2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: received
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,2,3
    label0: Constellation
    num_tabs: '1'
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_file_sink_0, '0']
- [blocks_add_const_vxx_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_add_const_vxx_0_1, '0', blocks_file_sink_0_1, '0']
- [blocks_add_const_vxx_0_1_0, '0', blocks_file_sink_0_1_0, '0']
- [blocks_add_const_vxx_0_2, '0', blocks_file_sink_0_2, '0']
- [blocks_add_const_vxx_0_3, '0', blocks_file_sink_0_3, '0']
- [blocks_char_to_short_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_char_to_short_0_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_char_to_short_0_1, '0', blocks_add_const_vxx_0_1, '0']
- [blocks_char_to_short_0_1_0, '0', blocks_add_const_vxx_0_1_0, '0']
- [blocks_char_to_short_0_2, '0', blocks_add_const_vxx_0_2, '0']
- [blocks_char_to_short_0_3, '0', blocks_add_const_vxx_0_3, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [blocks_wavfile_source_0_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0_0, '1', blocks_float_to_complex_0, '1']
- [digital_constellation_decoder_cb_0, '0', blocks_char_to_short_0_1, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0_0_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0_0_2, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0_0_3, '0']
- [digital_constellation_decoder_cb_0, '0', digital_map_bb_0_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_map_bb_0_0_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_map_bb_0_0_0_0_1, '0']
- [digital_constellation_decoder_cb_0, '0', digital_map_bb_0_0_0_1, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_diff_decoder_bb_0_0, '0', blocks_char_to_short_0, '0']
- [digital_diff_decoder_bb_0_0_0, '0', blocks_char_to_short_0_0, '0']
- [digital_diff_decoder_bb_0_0_0_0, '0', digital_diff_decoder_bb_0_0_0, '0']
- [digital_diff_decoder_bb_0_0_1, '0', blocks_char_to_short_0_2, '0']
- [digital_diff_decoder_bb_0_0_1_0, '0', digital_diff_decoder_bb_0_0_1, '0']
- [digital_diff_decoder_bb_0_0_2, '0', digital_map_bb_0_0_0_0_0, '0']
- [digital_diff_decoder_bb_0_0_2, '0', digital_map_bb_0_0_0_2, '0']
- [digital_diff_decoder_bb_0_0_3, '0', blocks_char_to_short_0_1_0, '0']
- [digital_map_bb_0_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_map_bb_0_0_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_map_bb_0_0_0_0_0, '0', blocks_char_to_short_0_3, '0']
- [digital_map_bb_0_0_0_0_1, '0', digital_diff_decoder_bb_0_0_1_0, '0']
- [digital_map_bb_0_0_0_1, '0', digital_diff_decoder_bb_0_0_1_0, '0']
- [digital_map_bb_0_0_0_2, '0', blocks_char_to_short_0_3, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_costas_loop_cc_0, '0']

metadata:
  file_format: 1
