options:
  parameters:
    author: pentoo
    generate_options: no_gui
    id: d8psk_transmitter
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: constellation_9PSK_auto
  id: variable_constellation
  parameters:
    const_points: '[0.383+0.924j, 0.924+0.383j, 0.924-0.383j, 0.383-0.924j, -0.383-0.924j, -0.924-0.383j, -0.924+0.383j, -0.383+0.924j, 0]'
    dims: '1'
    precision: '8'
    rot_sym: '8'
    soft_dec_lut: '''auto'''
    sym_map: '[1,0,7,6,5,4,3,2,8]'
    type: calcdist
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1190550'
  states: {}
- name: throttle_rate
  id: variable
  parameters:
    value: '320000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '-8*256'
    type: short
  states: {}
- name: analog_const_source_x_0_1
  id: analog_const_source_x
  parameters:
    const: '-8'
    type: float
  states: {state: disabled}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: 1/0
    const: '1'
    type: short
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    comment: 1/0
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_short_0
  id: blocks_char_to_short
  parameters: {}
  states: {}
- name: blocks_char_to_short_0_0
  id: blocks_char_to_short
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    comment: i set this to 90 for some reason, trimming packets or make all_headers. wrong!
    delay: 85+1
    type: byte
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    comment: should be 0 if on/-1 off
    type: short
  states: {}
- name: blocks_divide_xx_0_0
  id: blocks_divide_xx
  parameters:
    comment: should be 0 if on/-1 off
    type: float
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/pentoo/defcon27_badge_sdr/signal.bin
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '.7'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '4'
    type: byte
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_skiphead_1
  id: blocks_skiphead
  parameters:
    num_items: '80'
    type: float
  states: {}
- name: blocks_skiphead_1_0
  id: blocks_skiphead
  parameters:
    num_items: '80'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: throttle_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '3'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: (4,4,4,0,4,0,4,0,2,4,6,0,0,0,0,0,6,4,2,0,0,0,4,4,2,7,7,4,6,7,5,6,    2,5,2,2, 6,6,2,7, 4,4,2,4, 4,1,6,7, 0,7,3,2,           5,4,3,5, 7,0,3,6, 4,0,7,3, 0,4,1,4, 4,2,7,4, 6,2,0,2, 0,7,6,6, 1,6,4,1, 3,1,4,4, 0,7,7,3, 5,2,7,7    ,7,7,3,0,3,1,6,4,4,     8,8,8,   0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0)
  states: {state: disabled}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    comment: 800 pts
    repeat: 'False'
    type: byte
    vector: (0,0,0,0,0,0,0,0,0,0,0,4,0,0,0,0,0,0,0,0,0,0,0,0,0,0, 1,1,1,1,1,1,1,1, 2,2,2,2,2,2,2,2, 3,3,3,3,3,3,3,3, 4,4,4,4,4,4,4,4, 5,5,5,5,5,5,5,5, 6,6,6,6,6,6,6,6, 7,7,7,7,7,7,7,7, 8,8,8,8,8,8,8,8, 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0)
  states: {state: disabled}
- name: blocks_vector_source_x_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: (0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0, 8,8,8,8,8,8,8,8,      3,     0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,)
  states: {state: disabled}
- name: blocks_vector_source_x_0_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: (1,1,1,1,1,1,1,1,2,1,1,1,1,1,1,1,1,1,1,1,   5,7,  1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,    8,8,8,8,8,8,8,8,    1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1)
  states: {state: disabled}
- name: blocks_vector_source_x_0_0_0_0_0
  id: blocks_vector_source_x
  parameters:
    comment: |-
      All 8 possible headers I think
      use with no mapping
    repeat: 'False'
    type: byte
    vector: (0,4,0,4,4,0,0,4,4,2,6,0,0,0,0,0,0,2,6,4,4,4,4,0,4,2,3,4,0,2,3,6,8,8,8,8, 1,5,1,5,5,1,1,5,5,3,7,1,1,1,1,1,1,3,7,5,5,5,5,1,5,3,4,5,1,3,4,7,8,8,8,8, 2,6,2,6,6,2,2,6,6,4,0,2,2,2,2,2,2,4,0,6,6,6,6,2,6,4,5,6,2,4,5,0,8,8,8,8, 3,7,3,7,7,3,3,7,7,5,1,3,3,3,3,3,3,5,1,7,7,7,7,3,7,5,6,7,3,5,6,1,8,8,8,8, 4,0,4,0,0,4,4,0,0,6,2,4,4,4,4,4,4,6,2,0,0,0,0,4,0,6,7,0,4,6,7,2,8,8,8,8, 5,1,5,1,1,5,5,1,1,7,3,5,5,5,5,5,5,7,3,1,1,1,1,5,1,7,0,1,5,7,0,3,8,8,8,8, 6,2,6,2,2,6,6,2,2,0,4,6,6,6,6,6,6,0,4,2,2,2,2,6,2,0,1,2,6,0,1,4,8,8,8,8, 7,3,7,3,3,7,7,3,3,1,5,7,7,7,7,7,7,1,5,3,3,3,3,7,3,1,2,3,7,1,2,5,8,8,8,8,  0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0)
  states: {state: disabled}
- name: blocks_vector_source_x_0_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: (4,4,4,0,4,0,4,0,2,4,6,0,0,0,0,0,6,4,2,0,0,0,4,4,2,7,7,4,6,7,5,6,0,6,5,0,3,2,7,1,0,2,4,2,3,4,0,7,0,7,3,2,1,2,0,0,6,4,2,1,0,0,3,4,2,7,7,6,2,3,7,3,7,4,0,2,2,4,3,5,4,5,3,4,2,3,4,4,0,7,7,3,5,2,7,7,5,   0,6,2,4,2,0,3,2,4,   0,8,8,0,   0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0)
  states: {state: disabled}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '16'
    file: /home/pentoo/defcon27_badge_sdr/trans_output.wav
    nchan: '2'
    samp_rate: samp_rate
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: constellation_9PSK_auto
    differential: 'False'
    excess_bw: 0.35*3
    samples_per_symbol: '4'
  states: {}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    modulus: '8'
  states: {state: disabled}
- name: digital_map_bb_0_0_0
  id: digital_map_bb
  parameters:
    comment: |-
      all wrong with no mask
      [5,4,3,2,1,0,7,6,0]  phase upside down
      [2,3,4,5,6,7,0,1,0] wrong, some swapped some not there
      [7,6,5,4,3,2,1,0,0] amp or phase inverted
      [3,2,1,0,7,6,5,4,0] amp or phase inv
      [3,2,1,0,7,6,5,4,3] exactly the same as above
      God damnit const was wrong, 2 in there twice. phase inverted now
      [1,0,7,6,5,4,3,2,0] phase inv
      [6,7,0,1,2,3,4,5,0] holy shit it's right!!!
    map: '[6,7,0,1,2,3,4,5,8]'
  states: {}
- name: digital_map_bb_0_0_0_0
  id: digital_map_bb
  parameters:
    map: '[1,0,7,6,5,4,3,2,0]'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: symbols
    label2: amp
    nconnections: '6'
    size: '550'
    srate: samp_rate
    style3: '3'
    style4: '3'
    type: float
    ymax: '8'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: symbols
    label2: amp
    size: '550'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: symbols
    size: '240'
    srate: samp_rate
    type: float
  states: {state: disabled}

connections:
- [analog_const_source_x_0, '0', blocks_divide_xx_0, '1']
- [analog_const_source_x_0_1, '0', blocks_divide_xx_0_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_short_to_float_0, '0']
- [blocks_add_const_vxx_0_0, '0', blocks_multiply_xx_0, '0']
- [blocks_add_const_vxx_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_short_0, '0', blocks_divide_xx_0, '0']
- [blocks_char_to_short_0_0, '0', blocks_short_to_float_0_0, '0']
- [blocks_complex_to_float_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_complex_to_float_0, '1', blocks_multiply_xx_0_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_time_sink_x_0, '3']
- [blocks_delay_0, '0', blocks_char_to_float_0, '0']
- [blocks_delay_0, '0', blocks_char_to_short_0, '0']
- [blocks_divide_xx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_divide_xx_0_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_file_source_0, '0', blocks_repeat_0, '0']
- [blocks_file_source_0, '0', digital_map_bb_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_complex_to_float_0, '0']
- [blocks_multiply_xx_0, '0', blocks_skiphead_1, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0, '4']
- [blocks_multiply_xx_0_0, '0', blocks_skiphead_1_0, '0']
- [blocks_multiply_xx_0_0, '0', qtgui_time_sink_x_0, '5']
- [blocks_pack_k_bits_bb_0, '0', digital_constellation_modulator_0, '0']
- [blocks_repeat_0, '0', blocks_delay_0, '0']
- [blocks_short_to_float_0, '0', blocks_multiply_xx_0, '0']
- [blocks_short_to_float_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_short_to_float_0_0, '0', blocks_divide_xx_0_0, '0']
- [blocks_skiphead_1, '0', blocks_wavfile_sink_0, '0']
- [blocks_skiphead_1_0, '0', blocks_wavfile_sink_0, '1']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_vector_source_x_0, '0', blocks_repeat_0, '0']
- [blocks_vector_source_x_0, '0', digital_map_bb_0_0_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_repeat_0, '0']
- [blocks_vector_source_x_0_0, '0', digital_map_bb_0_0_0, '0']
- [blocks_vector_source_x_0_0_0, '0', blocks_char_to_short_0_0, '0']
- [blocks_vector_source_x_0_0_0, '0', blocks_repeat_0, '0']
- [blocks_vector_source_x_0_0_0, '0', digital_map_bb_0_0_0, '0']
- [blocks_vector_source_x_0_0_0_0, '0', blocks_repeat_0, '0']
- [blocks_vector_source_x_0_0_0_0, '0', digital_map_bb_0_0_0, '0']
- [blocks_vector_source_x_0_0_0_0_0, '0', blocks_repeat_0, '0']
- [blocks_vector_source_x_0_0_0_0_0, '0', digital_map_bb_0_0_0, '0']
- [blocks_vector_source_x_0_1, '0', blocks_repeat_0, '0']
- [blocks_vector_source_x_0_1, '0', digital_map_bb_0_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_map_bb_0_0_0, '0', blocks_unpack_k_bits_bb_0, '0']

metadata:
  file_format: 1
