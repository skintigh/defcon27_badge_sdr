options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: dec
  id: variable
  parameters:
    value: int(interp*samp_rate/bw)
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    comment: |-
      was 10.55515e6
      10.579e6 is supposedly the center
      10.279e6 to visualize sidebands in baudline
    min_len: '2000'
    orient: Qt.Horizontal
    start: '0'
    step: '1000'
    stop: 10.8e6
    value: 10.569e6
  states: {}
- name: interp
  id: variable
  parameters:
    value: '3'
  states: {}
- name: nyquist_rate
  id: variable
  parameters:
    comment: |-
      The sample rate 
      MUST be greater 
      than or equal to 
      the Nyquist rate!

      HackRF Max=20e6
    value: (10.569e6 + 200000 - freq) * 2
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1190550'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '16'
    file: /home/pentoo/defcon27_badge_sdr/recorder.wav
    nchan: '2'
    samp_rate: int(samp_rate)
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '0'
    comment: |-
      was 10.554MHz
      gains were 69 30 30
    freq0: freq
    gain0: '41'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: bw
    fc: '0'
    fftsize: '1024'
    rate: '1000'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: bw
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
    update_time: '0.000010000010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: needed?
    decim: dec
    interp: interp
    taps: ''
    type: ccc
  states: {}

connections:
- [blocks_complex_to_float_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_float_0, '1', blocks_wavfile_sink_0, '1']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0, '0']
- [osmosdr_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_float_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
