options:
  parameters:
    author: Seth Kintigh
    description: display a waterfall of the FSK section 1 of the signal
    generate_options: qt_gui
    id: section_1_waterfall
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '3200'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_source_0_1
  id: blocks_wavfile_source
  parameters:
    comment: 1.2M sample rate
    file: /home/pentoo/defcon27_badge_sdr/recordings/recorded_10.5551_PCsync_0PPM_119055_short.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '64'
    type: complex
    update_time: '0.0000000010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_float_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_wavfile_source_0_1, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0_1, '1', blocks_float_to_complex_0, '1']

metadata:
  file_format: 1
