options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: dec
  id: variable
  parameters:
    value: int(interp*samp_rate/bw)
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    min_len: '2000'
    orient: Qt.Horizontal
    start: 10.3e6
    step: '1000'
    stop: 10.8e6
    value: 10.554e6
  states: {}
- name: interp
  id: variable
  parameters:
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.2e6
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '16'
    file: /home/pentoo/Desktop/10554kHz_2400kps_69_30_30db_b.wav
    nchan: '2'
    samp_rate: int(bw)
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '30'
    freq0: freq
    gain0: '69'
    gain_mode0: 'False'
    if_gain0: '30'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: bw
    fc: '0'
    fftsize: '1024'
    rate: '1000'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: bw
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
    update_time: '0.000000000010'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: dec
    interp: interp
    taps: ''
    type: ccc
  states: {}

connections:
- [blocks_complex_to_float_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_float_0, '1', blocks_wavfile_sink_0, '1']
- [osmosdr_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_float_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
