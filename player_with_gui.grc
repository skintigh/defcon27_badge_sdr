options:
  parameters:
    author: asd
    generate_options: qt_gui
    id: player
    output_language: python
    run_options: run
    title: asdasdas
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Freq
    orient: Qt.Horizontal
    start: 10.3e6
    step: '10000'
    stop: 10.6e6
    value: 10.552e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1200000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1190550'
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '.50'
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/pentoo/defcon27_badge_sdr/synthetic_signal.wav
    nchan: '2'
    repeat: 'False'
  states: {state: disabled}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    comment: 1.2Ms 10.552
    file: /home/pentoo/defcon27_badge_sdr/recorder_10.552_PCsync_0PPM_short.wav
    nchan: '2'
    repeat: 'True'
  states: {state: disabled}
- name: blocks_wavfile_source_0_1
  id: blocks_wavfile_source
  parameters:
    comment: 1.2M sample rate
    file: /home/pentoo/defcon27_badge_sdr/recorded_example_shorter_3.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '0'
    bw0: '300000'
    freq0: freq
    gain0: '-20'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    plottime: 'False'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}

connections:
- [blocks_float_to_complex_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', osmosdr_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [blocks_wavfile_source_0_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0_0, '1', blocks_float_to_complex_0, '1']
- [blocks_wavfile_source_0_1, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0_1, '1', blocks_float_to_complex_0, '1']

metadata:
  file_format: 1
